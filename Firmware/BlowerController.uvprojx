# Keil uVision project BlowerController.uvprojx, settings and files
target BlowerController (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: BlowerController +hex
  c flags: Optim=1 v6Lang=3 v6LangP=3
  c define: STM32F10X_MD
  c include: .\User;.\Startup
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c
  group Startup
    ./Startup/: startup_stm32f10x_md.s
